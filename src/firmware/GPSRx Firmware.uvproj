# Keil uVision project GPSRx Firmware.uvproj, settings and files
target CY7C68013A - Run (MCS-51)
  device: EZ-USB FX2LP (CY7C68XXX-X) Cypress
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0xE000-0xE1FF) CLOCK(48000000) MODDP2
  output: GPSRx Firmware +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Code
    ./src/: dscr.a51 main.c periph.c GPSRx.h
  group Libraries
    ./EZ-USB FX2LP/lib/: EZUSB.LIB
  group Object Files
    ./EZ-USB FX2LP/lib/: USBJmpTb.OBJ
